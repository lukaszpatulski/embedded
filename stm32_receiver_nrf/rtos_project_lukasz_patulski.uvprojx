# Keil uVision project rtos_project_lukasz_patulski.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtos_project_lukasz_patulski
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\gpio;.;.\NRF24L01;.\interrupt;.\sleep;.\adc
  memory RVCT4: ROM 0x8000000 size 0xfc01
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./gpio/: stm32f10x_gpio.c leds.cpp
    ./: stm32f10x_rcc.c main.cpp stm32f10x_dbgmcu.c
  group NRF24L01
    ./NRF24L01/: nrf24L01.cpp
  group Interrupt
    ./interrupt/: stm32f1xx_it.cpp
  group sleep
    ./sleep/: sleep.cpp
  group adc
    ./adc/: adc.cpp
software components: CMSIS:CORE 4.2.0, CMSIS:RTOS:Keil RTX 4.79.0, Device:Startup 1.0.0
